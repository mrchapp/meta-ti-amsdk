require ti-sysbios.inc

PV = "6_21_00_13"
LIC_FILES_CHKSUM = "file://docs/license/TSPA_License_Agreement_DSP_BIOS.html;md5=51bb513752fb744b75eb8ed6376c7d97"

SRC_URI[sysbiosbin.md5sum] = "2cf2201b69375ce608caee52c600323f"
SRC_URI[sysbiosbin.sha256sum] = "0b74c7a6a40086de4728250aa249454238f38e41f2e90365a1bca8c128b6e97a"

TI_BIN_UNPK_CMDS="Y: qY:workdir:Y"
