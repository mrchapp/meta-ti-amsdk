require ti-ipc-legacy.inc

PV = "1_00_05_60"

LIC_FILES_CHKSUM = "file://ipc_${PV}_release_notes.html;md5=40c2a43f82d273d5eaf1313c61662f00"

SRC_URI[ipczip.md5sum] = "2dc790eda42790c47859fe7ee5d15391"
SRC_URI[ipczip.sha256sum] = "22366ce6f071438124605b1fe01ee69bfc5cb1738a82eb6772cb792b207d8e0a"
