require ti-xdais.inc

PV = "6_25_01_08"

LIC_FILES_CHKSUM = "file://xdais_${PV}_manifest.html;md5=c525d8a756f15340401c808af317f1f4"

SRC_URI[xdaistarball.md5sum] = "5f284e0721f4f080c9adc6271387c0f9"
SRC_URI[xdaistarball.sha256sum] = "88866b1bbd3992141f47f7a672cd4a2fbeef729d582312a06a1f269a32dded88"
