require ti-edma3lld-internal.inc

PV = "02_00_01_04"
LIC_FILES_CHKSUM = "file://packages/ti/sdo/edma3/drv/edma3_drv.h;md5=59a3b0c360ed4de271b9a2dd1cd066ed"

SRC_URI[edma3lldtarball.md5sum] = "5ffa34f9bfc59545ab2ff845acb7b78b"
SRC_URI[edma3lldtarball.sha256sum] = "0ed78cd495160c437dc781f75dfe762af161d4479592b953903a8725ffd9dc6d"
